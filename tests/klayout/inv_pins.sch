v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {asap7_devices/pmos_rvt/pmos_rvt.sym} 0 0 0 0 {name=M1 l=20n nfin=3 nf=2 m=1}
C {asap7_devices/nmos_rvt/nmos_rvt.sym} 0 100 0 0 {name=M2 l=20n nfin=2 nf=2 m=1}
C {lab_pin.sym} 20 -30 0 0 {name=l1 lab=VDD}
C {lab_pin.sym} 20 0 0 0 {name=l2 lab=VDD}
C {lab_pin.sym} -20 0 0 1 {name=l3 lab=A}
C {lab_pin.sym} 20 30 0 0 {name=l4 lab=Y}
C {lab_pin.sym} 20 70 0 0 {name=l5 lab=Y}
C {lab_pin.sym} -20 100 0 1 {name=l6 lab=A}
C {lab_pin.sym} 20 100 0 0 {name=l7 lab=VSS}
C {lab_pin.sym} 20 130 0 0 {name=l8 lab=VSS}
C {ipin.sym} -200 0 0 0 {name=p1 lab=A}
C {opin.sym} 200 50 0 0 {name=p2 lab=Y}
C {iopin.sym} -200 -60 0 0 {name=p3 lab=VDD}
C {iopin.sym} -200 160 0 0 {name=p4 lab=VSS}
